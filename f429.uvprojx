# Keil uVision project f429.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
    ../../park sensor/park sensor/stm32f429/LIBRARIES/: tm_stm32f4_adc.c tm_stm32f4_adc.h tm_stm32f4_adc.rar tm_stm32f4_all.rar tm_stm32f4_am2301.c tm_stm32f4_am2301.h tm_stm32f4_bmp180.c tm_stm32f4_bmp180.h tm_stm32f4_dac.c tm_stm32f4_dac.h tm_stm32f4_dac.rar tm_stm32f4_dac_signal.c tm_stm32f4_dac_signal.h tm_stm32f4_delay.rar tm_stm32f4_disco.rar tm_stm32f4_ds18b20.c tm_stm32f4_ds18b20.h tm_stm32f4_ds18b20.rar tm_stm32f4_ds1307.c tm_stm32f4_ds1307.h tm_stm32f4_ds1307.rar tm_stm32f4_exti.c tm_stm32f4_exti.h tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_fonts.c tm_stm32f4_fonts.h tm_stm32f4_fonts.rar tm_stm32f4_gps.c tm_stm32f4_gps.h tm_stm32f4_hd44780.c tm_stm32f4_hd44780.h tm_stm32f4_hd44780.rar tm_stm32f4_i2c.c tm_stm32f4_i2c.h tm_stm32f4_i2c.rar tm_stm32f4_ili9341.c tm_stm32f4_ili9341.h tm_stm32f4_ili9341.rar tm_stm32f4_ili9341_button.c tm_stm32f4_ili9341_button.h tm_stm32f4_ili9341_button.rar tm_stm32f4_ili9341_ltdc.c tm_stm32f4_ili9341_ltdc.h tm_stm32f4_keypad.c tm_stm32f4_keypad.h tm_stm32f4_l3gd20.c tm_stm32f4_l3gd20.h tm_stm32f4_library_template.c tm_stm32f4_library_template.h tm_stm32f4_lis302dl_lis3dsh.c tm_stm32f4_lis302dl_lis3dsh.h tm_stm32f4_mfrc522.c tm_stm32f4_mfrc522.h tm_stm32f4_nrf24l01.c tm_stm32f4_nrf24l01.h tm_stm32f4_onewire.c tm_stm32f4_onewire.h tm_stm32f4_onewire.rar tm_stm32f4_pcd8544.c tm_stm32f4_pcd8544.h tm_stm32f4_pcd8544.rar tm_stm32f4_pwm.c tm_stm32f4_pwm.h tm_stm32f4_rng.c tm_stm32f4_rng.h tm_stm32f4_rotary_encoder.c tm_stm32f4_rotary_encoder.h tm_stm32f4_rs485.c tm_stm32f4_rs485.h tm_stm32f4_rtc.c tm_stm32f4_rtc.h tm_stm32f4_rtc.rar tm_stm32f4_sdram.c tm_stm32f4_sdram.h tm_stm32f4_sdram.rar tm_stm32f4_softcrc.c tm_stm32f4_softcrc.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_spi.rar tm_stm32f4_stmpe811.c tm_stm32f4_stmpe811.h tm_stm32f4_stmpe811.rar tm_stm32f4_timer_properties.c tm_stm32f4_timer_properties.h tm_stm32f4_usart.c tm_stm32f4_usart.h tm_stm32f4_usart.rar tm_stm32f4_usb_hid_device.c tm_stm32f4_usb_hid_device.h tm_stm32f4_usb_hid_host.c tm_stm32f4_usb_hid_host.h tm_stm32f4_usb_msc_host.c tm_stm32f4_usb_msc_host.h tm_stm32f4_usb_vcp.c tm_stm32f4_usb_vcp.h tm_stm32f4_watchdog.c tm_stm32f4_watchdog.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
